# Keil uVision project obstacleAvoidance.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.2.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: obstacleAvoidance
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X,USE_STDPERIPH_DRIVER
  c include: .\user\inc;.\firmware\CMSIS\core;.\firmware\CMSIS\device;.\firmware\n32g4fr_std_periph_driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ./firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ./firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ./firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c
  group USER
    ./user/src/: main.c n32g4fr_it.c usart.c rcc.c signal_process.c modbus.c
